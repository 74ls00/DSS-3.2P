# Repository 74ls00/DSS-3.2P

File README.md:

## Можете использовать этот проект как схему. Хотя всё уже куплено, дальнейшая работа заморожена в связи с отсутствием понятной прошивки, как она была в начальных версиях. Прошлые версии не поддерживают T12 и потому интереса не представляют для этого проекта. Кроме того есть идеалогические причины магического типа почему сборка этого устройства не желательна.

### Просмотреть этот проект на [CADLAB.io](https://cadlab.io/project/1240)  

### Прошлая конструкция [DSS-3V](https://github.com/74ls00/DSS-3V)

Компактный вариант лёгкой паяльной станции на базе доступных в продаже комплектующих.

Корпус Gainta G1188B

[Ссылки по проекту](https://74ls00.github.io/dss3v/Links.html)

Схема почти полностью отлажена.

Из деталей пока нет разъёмов, не определено наличие реле.

Цель проекта. Создать компактную, функциональную, а главное точную и простую в настройке паяльную станцию с хорошим паяльником и феном, в пределе 50-100 уё.

Точность температур китайских очень низкая, а высокая цена вызвана использованием линейного источника питания.

Нет готовых решений с хорошим паяльником, только отдельные варианты. Удобство такого фена тоже низкое.

## EAGLE design DSS3P.brd

Parts:
1K1: REK53; F4052
3C1, 3C2: 0.1m; XC15B8
3F1: 6A; SHK20L
3F2: 3A; SHK20L
3VD9, 4VD3, 4VD4, 4VD5, 4VD6, 4VD8, 4VD9, 4VD10, 4VD11, 4VD12: DIODE-SOD80C; SOD80C
4C1, 4C2, 4C3: 100n; C050-025X075
4D1, 4D2, 4D4: 74595D; DIL16
4D3, 4D5: ULN2003D; DIL16
4D6: 7486N; DIL14A
4HG1: KYX-4301AS1; KYX-4301AS-1
4HG2: KYX-4301AS2; KYX-4301AS-2
4HG3: KYX-4301AS3; KYX-4301AS
4HL1B: blue; LED2X5
4HL1R, 4HL9R: red; LED2X5
4HL2, 4HL3, 4HL4, 4HL5, 4HL6, 4HL7, 4HL8, 4HL10, 4HL11, 4HL12, 4HL13, 4HL14, 4HL15, 4HL16: LEDSQR2X5; LED2X5
4HL9B: green; LED2X5
4HL17: DUOLED2X5
4HL20: EXT; LED2X5
4HL21: PREH; LED2X5
4HL22: Solder2; LED2X5
4J1: 1k; R1206W
4J2, 4J3, 4J4, 4R17: 0; R1206W
4R1: 220; 0204/7
4R2: R-EU_R1206W; R1206W
4R3: R-EU_0207/15; 0207/15
4R4, 4R5, 4R6, 4R7, 4R8: R-EU_0204/7; 0204/7
4R9, 4R14: 470; M0805
4R10: 470; R1206W
4R11: 470; R0805
4R13: 470; 0207/10
4R15, 4R30A, 4R30B: 10k; R1206W
4R16: 680; M0805
4S5, 4S6, 4S7, 4S8, 4S9, 4S10, 4S11, 4S12: 40-XX; B3F-40XX; MPN B3F-4000
4VD1: DIODE-D-5; D-5
4VD2: DIODE-DO41-10; DO41-10
4VD7: 1N4148; SOD80C
BFRAME2: _SYMBOL_BFRAME; BFRAME
DISPL2: MA03-2
JD, JD3: SJ
JI: SJ
L1: LFLF-10X13; LF-10X13
LED: MA04-2
MFRAME: _SYMBOL_MFRAME; MFRAME
MFRAME_D: _SYMBOL_MFRAME; MFRAME
POW_SW: M02; 02P
PW0E: CON_2P; CON_PWR_2PIN4MM
PWO: CON_2P; CON_PWR_2PIN4MM
PWON1, PWON2: PINHD-1X1; 1X01
RT: NTC-20-05; B57164; MPN B57164K474K52
S1, S2, S3, S4: 40-XX; B3F-40XX; MPN B3F-4000
U$7, U$10: PIN; PIN_POW
_TPLATE: _SYMBOLTFRAME_R; TFRAME_R

Connections:
A: 4HG1.11 (A), 4HG2.11 (A), 4HG3.11 (A), 4HL2.A, 4HL9R.A, 4HL10.A, 4R3.2
B: 4HG1.7 (B), 4HG2.7 (B), 4HG3.7 (B), 4HL1B.A, 4R1.2
C: 4HG1.4 (C), 4HG2.4 (C), 4HG3.4 (C), 4HL7.A, 4HL15.A, 4R8.2
D: 4HG1.2 (D), 4HG2.2 (D), 4HG3.2 (D), 4HL5.A, 4HL13.A, 4R5.2
E: 4HG1.1 (E), 4HG2.1 (E), 4HG3.1 (E), 4HL1R.A, 4HL4.A, 4HL12.A, 4R4.2
F: 4HG1.10 (F), 4HG2.10 (F), 4HG3.10 (F), 4HL3.A, 4HL9B.A, 4HL11.A, 4R2.2
G: 4HG1.5 (G), 4HG2.5 (G), 4HG3.5 (G), 4HL8.A, 4HL16.A, 4HL17.AR, 4R7.2
H: 4HG1.3 (DP), 4HG2.3 (DP), 4HG3.3 (DP), 4HL14.A, 4HL17.AG, 4J4.1, 4R6.2
HL6: 4HL6.A, 4J4.2
unnamed: 1K1.P1, 1K1.P2, PWON1.1, U$7.P$1
unnamed: 3F1.1A (1), 3F2.1A (1), U$10.P$1
unnamed: 4D5.15 (O2), 4R13.1, 4VD9.C
unnamed: 3C1.1, L1.1, PWO.2
unnamed: 4HL2.K (C), 4HL3.K (C), 4HL4.K (C), 4HL5.K (C), 4HL6.K (C), 4HL7.K (C), 4HL8.K (C), 4R14.2
unnamed: 1K1.1, 3VD9.C, POW_SW.1
unnamed: 4D1.14 (SER), 4D6.3 (Y), JD3.1
unnamed: 4VD1.A, S1.1 (S), S1.2 (S1)
unnamed: 4VD3.A, S3.1 (S), S3.2 (S1)
unnamed: 4VD2.A, S2.1 (S), S2.2 (S1)
unnamed: 4VD4.A, S4.1 (S), S4.2 (S1)
unnamed: 4D1.15 (QA), 4R1.1
unnamed: 4D1.1 (QB), 4R2.1
unnamed: 4D1.2 (QC), 4R3.1
unnamed: 4D1.3 (QD), 4R4.1
unnamed: 4HL22.K (C), LED.1
unnamed: 4HL21.K (C), LED.4
unnamed: 4HL20.K (C), LED.2
unnamed: 4D3.11 (O6), 4R17.1
unnamed: 4D1.4 (QE), 4R5.1
unnamed: 4D1.13 (G), 4J1.1
unnamed: 4D1.5 (QF), 4R6.1
unnamed: 4D1.6 (QG), 4R7.1
unnamed: 4R16.1, JI.2
unnamed: 1K1.S1 (S), 1K1.S2 (S), PW0E.1, PWON2.1, RT.2
unnamed: 3F1.2A (2), PW0E.2
unnamed: 4D4.12 (RCK), 4J2.2
unnamed: 1K1.2, 3VD9.A, POW_SW.2
unnamed: 4D1.7 (QH), 4R8.1
unnamed: 4D3.13 (O4), 4HG1.9 (CA2), 4VD3.C
unnamed: 4D3.12 (O5), 4HG1.12 (CA1), 4VD1.C
unnamed: 4D3.14 (O3), 4HG1.8 (CA3), 4VD2.C
unnamed: 4D3.16 (O1), 4HL1B.K (C), 4HL1R.K (C), 4HL9B.K (C), 4HL9R.K (C), 4HL17.K (C), 4VD4.C
unnamed: 4HL20.A, 4R10.1
unnamed: 4R14.1, 4R17.2, 4VD6.C
unnamed: 4HL21.A, 4R11.1
unnamed: 4D3.15 (O2), 4HG2.12 (CA1), 4VD5.C
unnamed: 4D5.16 (O1), 4HG3.12 (CA1), 4VD12.C
unnamed: 4HL10.K (C), 4HL11.K (C), 4HL12.K (C), 4HL13.K (C), 4HL14.K (C), 4HL15.K (C), 4HL16.K (C), 4R13.2
unnamed: 4D5.11 (O6), 4HG2.9 (CA2), 4VD7.C
unnamed: 4D5.12 (O5), 4HG2.8 (CA3), 4VD8.C
unnamed: 4D5.13 (O4), 4HG3.9 (CA2), 4VD11.C
unnamed: 4D5.14 (O3), 4HG3.8 (CA3), 4VD10.C
unnamed: 4HL22.A, 4R9.1
unnamed: 3C2.2, L1.2, RT.1
unnamed: 3C2.1, 3F2.2A (2), L1.4
unnamed: 4S5.1 (S), 4S5.2 (S1), 4VD5.A
unnamed: 4S6.1 (S), 4S6.2 (S1), 4VD6.A
unnamed: 4S7.1 (S), 4S7.2 (S1), 4VD7.A
unnamed: 4S8.1 (S), 4S8.2 (S1), 4VD8.A
unnamed: 4S9.1 (S), 4S9.2 (S1), 4VD9.A
unnamed: 4S11.1 (S), 4S11.2 (S1), 4VD11.A
unnamed: 4S10.1 (S), 4S10.2 (S1), 4VD10.A
unnamed: 4S12.1 (S), 4S12.2 (S1), 4VD12.A
unnamed: 4D2.7 (QH), 4D3.1 (I1)
unnamed: 4D2.6 (QG), 4D3.2 (I2)
unnamed: 4D2.5 (QF), 4D3.3 (I3)
unnamed: 4D2.4 (QE), 4D3.4 (I4)
unnamed: 4D2.3 (QD), 4D3.5 (I5)
unnamed: 4D2.2 (QC), 4D3.6 (I6)
unnamed: 4D2.1 (QB), 4D3.7 (I7)
unnamed: 4D4.7 (QH), 4D5.1 (I1)
unnamed: 4D4.6 (QG), 4D5.2 (I2)
unnamed: 4D4.5 (QF), 4D5.3 (I3)
unnamed: 4D4.4 (QE), 4D5.4 (I4)
unnamed: 4D4.3 (QD), 4D5.5 (I5)
unnamed: 4D4.2 (QC), 4D5.6 (I6)
unnamed: 4D4.1 (QB), 4D5.7 (I7)
POW2: 3C1.2, L1.3, PWO.1
_+5V: 4C1.2, 4C2.2, 4C3.2, 4D1.10 (SCL), 4D1.16 (VCC), 4D2.10 (SCL), 4D2.16 (VCC), 4D4.10 (SCL), 4D4.16 (VCC), 4D6.14 (+UB), 4R9.2, 4R10.2, 4R11.2, 4R15.2, 4R30A.1, DISPL2.5, LED.3
_CLK: 4D1.11 (SCK), 4J3.2, DISPL2.1
_CLK-: 4D2.11 (SCK), 4D4.11 (SCK), 4J3.1
_DATA: 4D2.14 (SER), 4D6.11 (Y), JD.2
_DATA0: 4D6.13 (B), DISPL2.4, JD.1
_DATA2: 4D2.9 (QH*), 4D4.14 (SER)
_DATA3: 4D4.9 (QH*), 4D6.2 (B), JD3.2
_DSEL: 4D6.1 (A), 4D6.4 (A), 4D6.5 (B), 4D6.9 (A), 4D6.10 (B), 4D6.12 (A), 4R15.1, JI.1
_GND: 4C1.1, 4C2.1, 4C3.1, 4D1.8 (GND), 4D2.8 (GND), 4D2.13 (G), 4D3.8 (GND), 4D4.8 (GND), 4D4.13 (G), 4D5.8 (GND), 4D6.7 (-UB), 4J1.2, 4R16.2, 4R30B.2, DISPL2.3
_KEY: 4R30A.2, 4R30B.1, 4S5.3, 4S5.4 (P1), 4S6.3, 4S6.4 (P1), 4S7.3, 4S7.4 (P1), 4S8.3, 4S8.4 (P1), 4S9.3, 4S9.4 (P1), 4S10.3, 4S10.4 (P1), 4S11.3, 4S11.4 (P1), 4S12.3, 4S12.4 (P1), DISPL2.6, S1.3, S1.4 (P1), S2.3, S2.4 (P1), S3.3, S3.4 (P1), S4.3, S4.4 (P1)
_STROB: 4D1.12 (RCK), 4D2.12 (RCK), 4J2.1, DISPL2.2

Notes on the sheet:
~220V
invert1
invert2

Parts:
1VT6: KT3102; TO92-ECB
2DA2: 7805; 78XXL
3B1: D3SBA60
3C3, 3C4: 1Mx250v_K73-17; C_22X10
3C5: 100x25v; E3,5-8
3C6: 1n; C050-025X075
3C7: 4.7x25v; E2,5-7
3C8: 100n; C050-025X075
3C8A: 4n7; C050-025X075
3C8B: C-EUC0805; C0805
3C9: 1n; C102-054X133
3C10: 470x2kv_K15-5; C075-032X103
3C11: 150mfx400v; C_D25-12
3C13, 3C16: 470x16v; E3,5-8
3C14, 3C15: 100x16v; E2,5-7
3C19: 1000x35v; E5-13
3D1: IR2153D; DIL8
3HL1: LED3MM
3J1, 3J2: J12MM; 12
3KK1, 3KK2, 3KK3, 3KK4: D03PA-PAD
3R1, 3R2: 150k 1w; P0613/15
3R3: 36k 2w; P0613/15
3R4: 15k; 0204/7
3R4B: R-EU_M0805; M0805
3R5: 27; 0309/10
3R6: 27; 0207/10
3R6B, 3R6B1: R-EU_M1206; M1206
3R7: 100 0.5w; P0613V
3R9: 1k; M0805
3R10: 220; M0805
3R11: 2k2; M0805
3R12: 220 0.5w; 0411/12
3VD1: D814D; ZDMETAL
3VD2, 3VD3: 1N4007; DO41-10
3VD4: SF36; DO41-10
3VD5, 3VD6, 3VD11, 3VD12: SS14; DO214AC
3VD10: 1N4004; DO41-10
3VT1, 3VT2: IRF740; TO220
+8V, +12V: PINHD-1X1; 1X01
C3: C-EUC1206; C1206
C5: 1000x35v; TT5D11L
D1, D2: SBL2040CT; TO220V
D3: SBL3040PT; TO247H
L2: L-USIRF-24; IRF24
L3: L-USTFI0410; TFI0410
PWI: CON_2P; CON_PWR_2PIN4MM
R1, R2, R3, R4, R5, R6: R-EU_R2010; R2010
T1: TRANS_EI33_; EI33

Connections:
+5V: 2DA2.OUT, 3C14.+, 3C15.+; also elsewhere on the board
+8V: 3KK4.B, 3VD5.C, 3VD6.C, D2.C, L2.1
+24V: 3C19.+, L3.2; also elsewhere on the board
DD: 3C7.-, 3D1.6 (VS), 3KK2.B, 3R7.1, 3VT1.3 (S), 3VT2.2 (D), T1.IN2
DU: 3J1.1, 3KK1.B, 3VT1.2 (D)
GD: 3R6.2, 3R6B.2, 3VT2.1 (G)
GND: 2DA2.GND, 3C10.2, 3C13.-, 3C14.-, 3C15.-, 3C16.-, 3C19.-, C3.2, T1.GND, T1.NC (GND); also elsewhere on the board
GU: 3R5.2, 3R6B1.2, 3VT1.1 (G)
IRCT: 3C6.1, 3D1.3 (CT), 3R4.1, 3R4B.1, 3VD10.A
IRD: 1VT6.C, 3R9.1, 3R10.1, 3VD10.C
IROD: 3D1.5 (LO), 3R6.1, 3R6B.1
IROU: 3D1.7 (HO), 3R5.1, 3R6B1.1
IRRT: 3D1.2 (RT), 3R4.2, 3R4B.2
IRTB: 1VT6.B, 3C8A.2, 3C8B.2, 3R11.2
IRVB: 3C7.+, 3D1.8 (VB), 3VD4.C
IRVCC: 3C5.+, 3C8.1, 3D1.1 (VCC), 3HL1.A, 3R3.2, 3R9.2, 3R12.1, 3VD1.C, 3VD4.A
unnamed: 3VD5.A, D2.A1, T1.8-1 (8V1)
unnamed: 3VD11.A, T1.IR1 (IROUT1)
unnamed: 3VD12.A, T1.IR2 (IROUT2)
unnamed: 3R12.2, 3VD11.C, 3VD12.C
unnamed: R1.1, R2.1, R3.1, R4.2, R5.2, R6.2
unnamed: D3.3 (A2), T1.24-1 (24V1)
unnamed: 3B1.+, 3J2.1
unnamed: 3R3.1, 3VD2.C, 3VD3.C
unnamed: 3B1.AC1, 3VD3.A, PWI.2
unnamed: D3.1 (A1), T1.24-2 (24V2)
unnamed: 3VD6.A, D2.A2, T1.8-2 (8V2)
unnamed: D1.A1, T1.12-1 (12V2)
unnamed: D1.A2, T1.12-2 (12V1)
unnamed: 3C16.+, +12V.1, C3.1, D1.C
unnamed: D3.2 (C), L3.1
unnamed: 2DA2.IN, 3C13.+, +8V.1, L2.2
unnamed: 3C3.2, 3C4.1, 3C9.1, 3R1.1, 3R2.2, T1.IN1
unnamed: 3HL1.K (C), 3R10.2
unnamed: 3C9.2, 3R7.2
unnamed: 3B1.AC2, 3VD2.A, PWI.1
POWER+: 3C3.1, 3C11.+, 3J1.2, 3J2.2, 3R1.2
POWER-: 1VT6.E, 3B1.-, 3C8A.1, 3C8B.1, 3C11.-, R1.2, R2.2, R3.2
POWER-T: 3C4.2, 3C5.-, 3C6.2, 3C8.2, 3C10.1, 3D1.4 (COM), 3R2.1, 3R11.1, 3VD1.A, 3VT2.3 (S), R4.1, R5.1, R6.1, T1.IR0 (IROUT0)

Notes on the sheet:
IRF740
1mfx400v K73-15 23x12mm
1mfx250v K73-15 22x9mm
1e5* 2w

Parts:
1C12, 1C13: 100n; C0805
1C14: C-EUC0805; C0805
1D3: ATMEGA168-AU; TQFP32-08
1D4: ULN2003N; DIL16_1
1Q1: CRYSTALHC49U-V; HC49U-V
1R30, 1R47, 2R3: 10k; M0805
1R31: 33k; 0207/10
1R32: R-EU_R1206W; R1206W
1VD1: 1N5819-T; DO41-7.6
1VD3, 2VD1, 2VD2, 4VD13: LL4148; SOD80C
1VT7, 4VT1: KT315; TO92-ECB
2C1, 2C2: 22; C0805
2C3, 2C4: x; C0805
2C5: x; C1206
2D1: CH340G; SOIC16
2D2: 74AC244DW; SO20W
2J1, 2J3, 2J7: 0; R1206W
2J2: 0; R3225W
2J4: 0; 07
2Q1: 12MHz; HC49U-V
2R1, 2R2: 20; R0805W
2R4: 1k; M1206
2R5: 5k6; 0207/10
2R6, 4R12: 1k; M0805
2VT1: BC847; SOT23
3C18: 100x16v; E2,5-7
4C4: 1mf; C1210
AIR_POWER: MA04-1
AVR_ISP: PROG_PC; DSS-P
B2: BUZZER
C1, C2: C-EUC0805; C0805
DISPL1: CON_7P_2
J2D2: SJ
S2_B, S2_S: PINHD-1X1; 1X01
S_REL: MA03-1
U$8, U$9, U$12, U$13: PIN2X8
USB-B: PN61729-S

Connections:
3V3: 2C3.1, 2D1.4 (V3), 2J2.1
+5V: 1VD1.A, B2.+ (1); also elsewhere on the board
+24V: 2R5.2, AIR_POWER.1, AIR_POWER.3; also elsewhere on the board
AIR: 1D3.11 (PD7(AIN1/PCINT23)), 1D4.6 (I6), U$12.P$3 (3)
BUZZER: 1D3.2 (PD4(T0/XCK/PCINT20)), 1R47.2, U$13.P$2 (2)
CLK: 1D3.28 (PC5(ADC5/SCL/PCINT13)), DISPL1.1, U$8.P$4 (4)
DATA: 1D3.26 (PC3(ADC3/PCINT11)), DISPL1.4, U$8.P$2 (2)
GERKON: 1D3.25 (PC2(ADC2/PCINT10)), U$8.P$1 (1); also elsewhere on the board
GND: 1C12.2, 1C13.2, 1C14.2, 1D3.3 (GND), 1D3.5 (GND), 1D3.21 (AGND), 1D4.8 (GND), 1VT7.E, 2C1.1, 2C2.1, 2C3.2, 2C4.1, 2C5.1, 2J1.1, 2J3.1, 2R6.1, 2VT1.2 (E), 3C18.-, 4C4.1, 4VT1.E, AVR_ISP.6, C1.2, C2.2, DISPL1.3, U$9.P$5 (5), U$13.P$3 (3), U$13.P$5 (5), USB-B.4, USB-B.S1, USB-B.S2; also elsewhere on the board
GND$80: 2D1.1 (GND), 2J1.2
GND$159: 2D2.10 (GND), 2J3.2
KEY(SCK): 1D3.17 (PB5(SCK/PCINT5)), 1R30.2, 2D2.11 (A1), 2D2.13 (A2), 2D2.14 (Y3), AVR_ISP.3, DISPL1.6, U$9.P$1 (1)
MISO: 2D1.9 (CTS), 2D2.16 (Y2)
MOSI: 2D1.13 (DTR), 2D2.8 (A4)
M_AIR: 1D4.11 (O6), AIR_POWER.4
M_FEN: 1D4.13 (O4); also elsewhere on the board
M_PRH: 1D4.12 (O5); also elsewhere on the board
unnamed: 1VT7.C, B2.- (2)
unnamed: 2R1.1, USB-B.2
unnamed: 1C14.1, 1R47.1, 1VT7.B
unnamed: 1R32.2, C1.1
unnamed: 4VT1.C, S2_S.1
unnamed: 2J7.2, AVR_ISP.7
unnamed: 2D2.20 (VCC), J2D2.1
unnamed: 4C4.2, 4R12.2, 4VT1.B, S2_B.1
unnamed: 4R12.1, 4VD13.C
unnamed: 2D1.6 (D-), 2R1.2
unnamed: 2C2.2, 2D1.8 (XO), 2Q1.2
unnamed: 2C1.2, 2D1.7 (XI), 2Q1.1
unnamed: 2R2.1, USB-B.3
unnamed: 2D1.5 (D+), 2R2.2
unnamed: 2VD1.A, USB-B.1
unnamed: 2D2.19 (G), 2J4.2, 2R3.1, 2VT1.3 (C)
unnamed: 2R4.2, 2VT1.1 (B)
PB0: 1D3.12 (PB0(ICP1/CLKO/PCINT0)), 1D4.7 (I7), U$12.P$4 (4)
PD3: 1D3.1 (PD3(INT1/OC2B/PCINT19)), 1D4.1 (I1), U$13.P$1 (1)
PD5: 1D3.9 (PD5(T1/OC0B/PCINT21)), 1D4.4 (I4), U$12.P$1 (1)
PD6: 1D3.10 (PD6(AIN0/OC0A/PCINT22)), 1D4.5 (I5), U$12.P$2 (2)
POWER: 1D4.10 (O7), AIR_POWER.2
PWM_EXT: 1D3.15 (PB3(MOSI/OC2A/PCINT3)), 2D2.12 (Y4), AVR_ISP.4, U$12.P$7 (7); also elsewhere on the board
PWM_FEN_P: 1D3.14 (PB2(SS/OC1B/PCINT2)), U$12.P$6 (6); also elsewhere on the board
PWM_PRH(MISO): 1D3.16 (PB4(MISO/PCINT4)), 2D2.4 (A2), AVR_ISP.1, U$12.P$8 (8); also elsewhere on the board
PWM_SOL_1: 1D3.13 (PB1(OC1A/PCINT1)), U$12.P$5 (5); also elsewhere on the board
PWM_SOL_2: 1D3.32 (PD2(INT0/PCINT18)), 4VD13.A, U$8.P$8 (8); also elsewhere on the board
RELAY_EXT: 1D3.7 (PB6(XTAL1/TOSC1/PCINT6)), 1D4.2 (I2), 1Q1.2, C2.1, U$13.P$7 (7)
RELAY_FEN: 1D3.8 (PB7(XTAL2/TOSC2/PCINT7)), 1D4.3 (I3), 1Q1.1, 1R32.1, U$13.P$8 (8)
RESET: 1D3.29 (PC6(/RESET/PCINT14)), 1R31.1, 2D2.18 (Y1), AVR_ISP.5, U$8.P$5 (5)
RX: 2D1.3 (RX), 2D2.5 (Y3)
RXD(TX): 1D3.30 (PD0(RXD/PCINT16)), 2D2.3 (Y4), AVR_ISP.8, U$8.P$6 (6)
R_EXT: 1D4.15 (O2), S_REL.2
R_FEN: 1D4.14 (O3), S_REL.3
R_PREH: 1D4.16 (O1), S_REL.1
SCK: 2D1.14 (RTS), 2D2.6 (A3)
STROB: 1D3.27 (PC4(ADC4/SDA/PCINT12)), DISPL1.2, U$8.P$3 (3)
TO_FAN: 1D3.19 (ADC6), U$9.P$3 (3); also elsewhere on the board
TX: 2D1.2 (TX), 2D2.2 (A1), 2D2.17 (A4)
TXD(RX): 1D3.31 (PD1(TXD/PCINT17)), 2D2.15 (A3), 2J7.1, U$8.P$7 (7)
T_PREHEAT: 1D3.23 (PC0(ADC0/PCINT8)), U$9.P$7 (7); also elsewhere on the board
T_SOLDER_1: 1D3.22 (ADC7), U$9.P$6 (6); also elsewhere on the board
T_SOLDER_2: 1D3.24 (PC1(ADC1/PCINT9)), U$9.P$8 (8); also elsewhere on the board
USB_SEL: 2D2.1 (G), 2J4.1, 2R4.1, 2R5.1, 2R6.2, AVR_ISP.10
VCC: 1C12.1, 1C13.1, 1D3.4 (VCC), 1D3.6 (VCC), 1D3.18 (AVCC), 1D3.20 (AREF), 1R30.1, 1R31.2, 1VD1.C, 1VD3.C, 2R3.2, 2VD1.C, 2VD2.A, 3C18.+, DISPL1.5, J2D2.2, U$9.P$2 (2), U$9.P$4 (4), U$13.P$4 (4), U$13.P$6 (6)
VCC_CH340G: 2C4.2, 2C5.2, 2D1.16 (VCC), 2J2.2, 2VD2.C
V_PROG: 1VD3.A, AVR_ISP.2

Notes on the sheet:
2J4 none 74*241 74*244

Parts:
1C2: 100n; C1206
1C4, 1C9, 1C11: 100n; C0805
1D1, 1D2: LM358D; SO08
1F1, 1F4: 2A; 1812
1R2, 1R4: 10k; RTRIM3296W
1R6: 1k; R0805
1R8, 1R14, 1R16: 1k; M0805
1R10, 1R12: 10k; M1206
1R18, 1R20: 100; RTRIM3296W
1R23, 1R25: 150k; RTRIM3296W
1R23A, 1R25A, 1R26, 1R29: 1M; M0805
1R38: 100; M1206
1R46: 100; R1206W
1R50: 3k; 0207/12
1R51, 1R52, 1R56, 1R57: 3k; M0805
1R55: 3k; R1206W
1SJ1, 1SJ2, 1SJ3, 1SJ4, 1SJ5, 1SJ6, 1SJ7, 1SJ8, 1SJ9, 1SJ50: SJ
1VD2, 1VD4, 1VD5, 1VD6, 1VD7, 1VD11: LL4148; SOD80C
1VT2, 1VT4: IRF7416; SO-8
1VT2B, 1VT4B: PMOS; TO220V
1VT3, 1VT5: IRFZ24N; DPACK_1
1VT3B, 1VT5B: NMOS; TO220V
SOLDER1, SOLDER2: CON_DIN5; DIN_5_FEMALE_SUPPORT

Connections:
+5V: 1R50.2, 1R55.2, 1SJ5.2, 1SJ7.2, 1VD2.A, 1VD11.A; also elsewhere on the board
+24FS1: 1F1.2, 1R51.2, 1SJ6.1, 1VT2.1 (S), 1VT2.2 (S), 1VT2.3 (S), 1VT2B.3 (S)
+24FS2: 1F4.2, 1R56.2, 1SJ1.1, 1VT4.1 (S), 1VT4.2 (S), 1VT4.3 (S), 1VT4B.3 (S)
+24LS1: 1SJ6.2, 1SJ50.1, 1VT2.5 (D), 1VT2.6 (D), 1VT2.7 (D), 1VT2.8 (D), 1VT2B.2 (D), SOLDER1.3
+24LS2: 1SJ1.2, 1SJ2.1, 1VT4.5 (D), 1VT4.6 (D), 1VT4.7 (D), 1VT4.8 (D), 1VT4B.2 (D), SOLDER2.3
+24V: 1F1.1, 1F4.1; also elsewhere on the board
-US1: 1R52.2, 1SJ9.1, 1VT5.D, 1VT5B.2 (D)
-US2: 1R57.2, 1SJ3.1, 1VT3.D, 1VT3B.2 (D)
GND: 1C2.2, 1C4.2, 1C9.2, 1C11.2, 1R14.1, 1R16.1, 1R18.1 (E), 1R18.2 (S), 1R20.1 (E), 1R20.2 (S), 1VD4.A, 1VD5.C, 1VD6.A, 1VD7.C, 1VT3.S, 1VT3B.3 (S), 1VT5.S, 1VT5B.3 (S), SOLDER1.2, SOLDER1.4, SOLDER1.GND1 (GND), SOLDER1.GND2 (GND), SOLDER2.2, SOLDER2.4, SOLDER2.GND1 (GND), SOLDER2.GND2 (GND); also elsewhere on the board
GNS1: 1R38.2, 1VT5.G, 1VT5B.1 (G)
GNS2: 1R46.2, 1VT3.G, 1VT3B.1 (G)
GPS1: 1R51.1, 1R52.1, 1VT2.4 (G), 1VT2B.1 (G)
GPS2: 1R56.1, 1R57.1, 1VT4.4 (G), 1VT4B.1 (G)
unnamed: 1SJ9.2, SOLDER1.5
unnamed: 1C4.1, 1R8.1, 1R12.1, 1SJ50.2, SOLDER1.1
unnamed: 1D1.6 (-IN), 1R14.2, 1R18.3 (A), 1R23.3 (A), 1R23A.1, 1R55.1
unnamed: 1SJ3.2, SOLDER2.5
unnamed: 1R4.2 (S), 1R4.3 (A), 1R8.2, 1SJ8.1
unnamed: 1R4.1 (E), 1SJ7.1, 1SJ8.2, 1VD2.C
unnamed: 1D2.2 (-IN), 1R16.2, 1R20.3 (A), 1R25.3 (A), 1R25A.1, 1R50.1
unnamed: 1D2.3 (+IN), 1R12.2, 1VD4.C, 1VD5.A
unnamed: 1R2.2 (S), 1R2.3 (A), 1R6.2, 1SJ4.1
unnamed: 1R2.1 (E), 1SJ4.2, 1SJ5.1, 1VD11.C
unnamed: 1C2.1, 1R6.1, 1R10.1, 1SJ2.2, SOLDER2.1
unnamed: 1D2.1 (OUT), 1R25.1 (E), 1R25.2 (S), 1R25A.2, 1R29.1
unnamed: 1D1.5 (+IN), 1R10.2, 1VD6.C, 1VD7.A
unnamed: 1D1.7 (OUT), 1R23.1 (E), 1R23.2 (S), 1R23A.2, 1R26.1
PWM_SOL_1: 1R38.1; also elsewhere on the board
PWM_SOL_2: 1R46.1; also elsewhere on the board
T_SOLDER_1: 1C11.1, 1R29.2; also elsewhere on the board
T_SOLDER_2: 1C9.1, 1R26.2; also elsewhere on the board

Notes on the sheet:
900 3 H+ 5 H- 2 GND 4 T- 1 T+
J1 900 J3 900 J2 t12
1VD6 T12
T12 1 3 H+ 2 GND

Parts:
1C1, 1C5, 1C8, 5C3, 5C6, 5C7, 5C10: 100n; C0805
1C17, 1C18, 1C19: 100nx400v; C102-043X133
1D1, 1D2: LM358D; SO08
1KK1, 1KK2, 1KK3: D03PA-PAD
1OK1, 1OK2, 1OK3: MOC3063; DIL6
1R1, 5R3: 10k; RTRIM3296W
1R5, 1R13: 1k; M0805
1R9, 5R11: 10k; M1206
1R17, 5R19: 100; RTRIM3296W
1R22, 5R24: 150k; RTRIM3296W
1R22A: R-EU_R0805; R0805
1R27: 1M; R1206W
1R33, 1R34, 1R35: 510; 0207/12
1R36, 1R37, 1R39, 1R40, 1R41: 390; P0613/15
1R42: 390; 0207/10
1R43, 1R44: 39; P0613/15
1R45: 39; 0207/10
1T1, 1T2, 1T3: BTA12-600; TO220DS
5R7, 5R15: 1k*; M0805
5R21: 33k; M1206
5R24A: R-EU_M0805; M0805
5R28: 1M; M0805
EXT: CON_2P; CON_PWR_2PIN4MM
FAN_C: MA06-2
PREH_C: MA06-2
PWFAN: CON_2P; CON_PWR_2PIN4MM
PWIE: CON_2P; CON_PWR_2PIN4MM
PWPRH: CON_2P; CON_PWR_2PIN4MM

Connections:
+5V: 1C5.1, 1D1.8 (V+), 1D2.8 (V+), 1R1.3 (A), 5C6.1, 5R3.3 (A), 5R21.2; also elsewhere on the board
+24V: FAN_C.1, FAN_C.2, PREH_C.1, PREH_C.2; also elsewhere on the board
D1O: 1D1.1 (OUT), 1R22.1 (E), 1R22.2 (S), 1R22A.1, 1R27.1
D1~I: 1D1.2 (-IN), 1R13.2, 1R17.2 (S), 1R17.3 (A), 1R22.3 (A), 1R22A.2
D2O: 1D2.7 (OUT), 5R24.1 (E), 5R24.2 (S), 5R24A.1, 5R28.1
D2~I: 1D2.6 (-IN), 5R15.2, 5R19.2 (S), 5R19.3 (A), 5R24.3 (A), 5R24A.2
GERKON: 5C7.1, 5R21.1, FAN_C.5, FAN_C.6; also elsewhere on the board
GND: 1C1.2, 1C5.2, 1C8.2, 1D1.4 (V-), 1D2.4 (V-), 1OK1.2 (C), 1OK2.2 (C), 1OK3.2 (C), 1R13.1, 1R17.1 (E), 5C3.2, 5C6.2, 5C7.2, 5C10.2, 5R15.1, 5R19.1 (E), FAN_C.7, FAN_C.8, PREH_C.7, PREH_C.8; also elsewhere on the board
M_FEN: FAN_C.3, FAN_C.4; also elsewhere on the board
M_PRH: PREH_C.3, PREH_C.4; also elsewhere on the board
unnamed: 1OK3.1 (A), 1R35.2
unnamed: 1OK3.6 (A2), 1R42.2
unnamed: 1OK2.6 (A2), 1R41.2
unnamed: 1OK1.6 (A2), 1R40.2
unnamed: 1C19.2, 1R39.1, 1T3.A1, PWFAN.2
unnamed: 1C17.1, 1R43.2
unnamed: 1C18.1, 1R44.2
unnamed: 1C19.1, 1R45.2
unnamed: 1R1.1 (E), 1R1.2 (S), 1R5.2
unnamed: 1D1.3 (+IN), 1R9.2
unnamed: 1D2.5 (+IN), 5R11.2
unnamed: 5R3.1 (E), 5R3.2 (S), 5R7.2
unnamed: 1OK3.4 (A1), 1R39.2, 1T3.G (G1)
unnamed: 1OK1.4 (A1), 1R36.2, 1T1.G (G1)
unnamed: 1OK1.1 (A), 1R33.2
unnamed: 1C17.2, 1R36.1, 1T1.A1, EXT.1
unnamed: 1OK2.4 (A1), 1R37.2, 1T2.G (G1)
unnamed: 1OK2.1 (A), 1R34.2
unnamed: 1C18.2, 1R37.1, 1T2.A1, PWPRH.1
PWM_EXT: 1R33.1; also elsewhere on the board
PWM_FEN_P: 1R35.1; also elsewhere on the board
PWM_PRH(MISO): 1R34.1; also elsewhere on the board
TI_FAN: 5C3.1, 5R7.1, 5R11.1, FAN_C.9, FAN_C.10
TI_PREHEAT: 1C1.1, 1R5.1, 1R9.1, PREH_C.9, PREH_C.10
TO_FAN: 5C10.1, 5R28.2; also elsewhere on the board
T_PREHEAT: 1C8.1, 1R27.2; also elsewhere on the board
~220V_A: 1KK3.B, 1R42.1, 1R45.1, 1T3.A2, EXT.2, PWIE.1, PWPRH.2
~220V_B: 1KK1.B, 1KK2.B, 1R40.1, 1R41.1, 1R43.1, 1R44.1, 1T1.A2, 1T2.A2, PWFAN.1, PWIE.2

Board: 2 copper layers, 399.7 x 251.8 mm, 343 parts (152 on the bottom side), 240 nets.

Other parts of the board:
BDIM1: PBS-11
U$3: STAND
U$11: IEC-320N

## EAGLE design DSS3_T12/DSS3_T12.brd

Parts:
1C1, 1C9: 100n; C0805
1C2: 100n; C1206
1D1, 1D2: LM358D; SO08
1F2: 2A; 1812
1R1: 3k; M0805
1R2: 10k; RTRIM3296W
1R3, 1R7: 3k; 0207/10
1R4, 1R26: 1M; M0805
1R5: 1k; 0207/10
1R6: 1k; R1206W
1R8: 180; M0805
1R10: 10k; M1206
1R14: 1k; M0805
1R18: 100; RTRIM3296W
1R23: 150k; RTRIM3296W
1R46: 100; M0805
1VD3, 1VD6, 1VD7: LL4148; SOD80C
1VT1, 1VT3: IRFZ24N; DPACK_1
D1: ZENER-DIODEDO34-7; DO34Z7
OK1: PC817; DIL04
Q1: SUP65P06-20; TO220
Q2: SUP75N06-08; TO220
Q3: BSO201SP; SO-8
SJ1, SJ3, SJ4: SJ
SJ2: SJW
SOLDER2: CON_DIN5; DIN_5_FEMALE_SUPPORT
SV1: MA04-1

Connections:
+5V: 1C1.1, 1D1.8 (V+), 1D2.8 (V+), 1VD3.A, SJ3.2, SV1.1
+24V: 1R1.2, 1R7.2, 1VT1.D, Q1.3 (S), Q3.1 (S), Q3.2 (S), Q3.3 (S), SJ2.1
GND: 1C1.2, 1C2.2, 1C9.2, 1D1.4 (V-), 1D2.4 (V-), 1R14.1, 1R18.1 (E), 1R18.2 (S), 1VD6.A, 1VD7.C, 1VT3.S, OK1.2 (C), Q2.3 (S), SOLDER2.2, SOLDER2.4, SOLDER2.GND1 (GND), SOLDER2.GND2 (GND), SV1.4
LM: 1D1.6 (-IN), 1D2.2 (-IN), 1R4.1, 1R14.2, 1R18.3 (A), 1R23.2 (S), 1R23.3 (A)
LO: 1D1.7 (OUT), 1D2.1 (OUT), 1R4.2, 1R23.1 (E), 1R26.1
LP: 1D1.5 (+IN), 1D2.3 (+IN), 1R10.2, 1VD6.C, 1VD7.A
MK: 1R8.2, 1R46.1, SV1.2
N1: 1R46.2, 1VT3.G, Q2.1 (G)
N2: 1R3.2, 1VT3.D, Q2.2 (D), SOLDER2.5
N3: 1R1.1, 1R3.1, Q1.1 (G), Q3.4 (G)
N4: 1F2.1, 1R5.1, 1VT1.S, D1.A, Q1.2 (D), Q3.5 (D), Q3.6 (D), Q3.7 (D), Q3.8 (D), SJ1.1, SJ2.2
unnamed: 1R7.1, OK1.4 (COL)
unnamed: 1F2.2, SOLDER2.3
unnamed: 1C2.1, 1R6.1, 1R10.1, SJ1.2, SOLDER2.1
unnamed: 1R5.2, 1VT1.G, D1.C, OK1.3 (EMIT)
unnamed: 1R8.1, OK1.1 (A)
unnamed: 1R2.1 (E), 1R2.2 (S), 1R6.2, SJ4.1
unnamed: 1R2.3 (A), 1VD3.C, SJ3.1, SJ4.2
OUT: 1C9.1, 1R26.2, SV1.3
