# Repository 74ls00/DSS-3.2P (continued)

## EAGLE design DSS3_T12/DSS3_T12.brd (continued)

Board: 2 copper layers, 160.0 x 100.0 mm, 36 parts (26 on the bottom side), 19 nets.

## EAGLE design DSS-3M1_/DSS-3M.brd

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12: C-EU050-025X075; C050-025X075
D1, D2: 1N4148DO35-7; DO35-7
IC1, IC2: LM358N; DIL08
IC3: ATMEGA168-AU; TQFP32-08
IC4: ULN2003AD; SO16
R1, R2, R3, R4, R6, R8, R10, R12, R13, R14, R15, R16, R25, R26, R27, R28, R29: R-EU_0204/7; 0204/7
R5, R7, R9, R11, R17, R18, R19, R20, R21, R22, R23, R24: R-TRIMM3296W; RTRIM3296W
R30: 33k; 0204/5
R31: 10k; 0204/5
R32: R-EU_0204/5; 0204/5
SG1: F/CM12P
SL1, SL2, SL4, SL10, SL11: M02; 02P
SL3, SL12: M03; 03P
SL5: DISPLAY; 06P
SL6: PROG_PC; 08P
SL7: M04; 04P
SL8, SL9: M05; 05P
T1: BC547; TO92

Connections:
+5V_C: C10.1, C11.1, D1.A, IC1.8 (V+), IC2.8 (V+), IC4.9 (CD+), R5.3 (A), R7.3 (A), R9.3 (A), R11.3 (A), R27.2, R30.2, R31.2, SG1.+ (1), SL5.5, SL10.1
BUZZER: IC3.2 (PD4(T0/XCK/PCINT20)), R32.2
CLK: IC3.28 (PC5(ADC5/SCL/PCINT13)), SL5.1
DATA: IC3.26 (PC3(ADC3/PCINT11)), SL5.3
GERKON: C1.1, IC3.25 (PC2(ADC2/PCINT10)), R27.1, SL3.3
GND_C: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, IC1.4 (V-), IC2.4 (V-), IC3.3 (GND), IC3.5 (GND), IC3.21 (AGND), IC4.8 (GND), R13.1, R14.1, R15.1, R16.1, R18.1 (E), R18.2 (S), R20.1 (E), R20.2 (S), R22.1 (E), R22.2 (S), R24.1 (E), R24.2 (S), SL1.1, SL2.1, SL3.1, SL4.1, SL5.6, SL6.6, SL7.4, SL8.1, SL8.2, SL9.4, SL9.5, SL10.2, SL11.1, SL12.2, T1.1 (E)
KEY: IC3.17 (PB5(SCK/PCINT5)), R31.1, SL5.4, SL6.3
MOTOR_AIR: IC3.11 (PD7(AIN1/PCINT23)), IC4.2 (I2)
MOTOR_FEN: IC3.9 (PD5(T1/OC0B/PCINT21)), IC4.4 (I4)
MOTOR_PREHEAT: IC3.10 (PD6(AIN0/OC0A/PCINT22)), IC4.3 (I3)
M_AIR: IC4.15 (O2), SL7.3
M_FEN: IC4.13 (O4), SL7.1
M_PRH: IC4.14 (O3), SL7.2
unnamed: R32.1, T1.2 (B)
unnamed: IC1.1 (OUT), R17.1 (E), R17.2 (S), R25.1
unnamed: SG1.- (2), T1.3 (C)
unnamed: IC1.7 (OUT), R19.1 (E), R19.2 (S), R26.1
unnamed: IC1.3 (+IN), R13.2, R17.3 (A), R18.3 (A)
unnamed: R1.2, R5.1 (E), R5.2 (S)
unnamed: IC1.6 (-IN), R8.2
unnamed: IC1.2 (-IN), R6.2
unnamed: C2.1, R1.1, R6.1, SL1.2
unnamed: IC1.5 (+IN), R14.2, R19.3 (A), R20.3 (A)
unnamed: R2.2, R7.1 (E), R7.2 (S)
unnamed: C3.1, R2.1, R8.1, SL2.2
unnamed: IC2.1 (OUT), R21.1 (E), R21.2 (S), R28.1
unnamed: IC2.7 (OUT), R23.1 (E), R23.2 (S), R29.1
unnamed: IC2.3 (+IN), R15.2, R21.3 (A), R22.3 (A)
unnamed: IC2.2 (-IN), R10.2
unnamed: C4.1, R3.1, R10.1, SL3.2
unnamed: R3.2, R9.1 (E), R9.2 (S)
unnamed: IC2.6 (-IN), R12.2
unnamed: IC2.5 (+IN), R16.2, R23.3 (A), R24.3 (A)
unnamed: R4.2, R11.1 (E), R11.2 (S)
unnamed: C5.1, R4.1, R12.1, SL4.2
POWER: IC4.16 (O1), SL11.2
PWM_EXT: IC3.15 (PB3(MOSI/OC2A/PCINT3)), SL6.4, SL8.4
PWM_FEN: IC3.14 (PB2(SS/OC1B/PCINT2)), SL8.3
PWM_PRH: IC3.16 (PB4(MISO/PCINT4)), SL6.1, SL8.5
PWM_SOL_1: IC3.13 (PB1(OC1A/PCINT1)), SL12.3
PWM_SOL_2: IC3.32 (PD2(INT0/PCINT18)), SL12.1
RELAY_EXT: IC3.7 (PB6(XTAL1/TOSC1/PCINT6)), IC4.6 (I6)
RELAY_FEN: IC3.8 (PB7(XTAL2/TOSC2/PCINT7)), IC4.5 (I5)
RELAY_POWER: IC3.12 (PB0(ICP1/CLKO/PCINT0)), IC4.1 (I1)
RELAY_PREHEAT: IC3.1 (PD3(INT1/OC2B/PCINT19)), IC4.7 (I7)
RESET: IC3.29 (PC6(/RESET/PCINT14)), R30.1, SL6.5
RXD: IC3.30 (PD0(RXD/PCINT16)), SL6.8
R_EXT: IC4.11 (O6), SL9.2
R_FEN: IC4.12 (O5), SL9.3
R_PRH: IC4.10 (O7), SL9.1
STROB: IC3.27 (PC4(ADC4/SDA/PCINT12)), SL5.2
TXD: IC3.31 (PD1(TXD/PCINT17)), SL6.7
T_FEN: C8.1, IC3.19 (ADC6), R28.2
T_PREHEAT: C6.1, IC3.23 (PC0(ADC0/PCINT8)), R25.2
T_SOLDER_1: C9.1, IC3.22 (ADC7), R29.2
T_SOLDER_2: C7.1, IC3.24 (PC1(ADC1/PCINT9)), R26.2
VCC: C12.1, D1.C, D2.C, IC3.4 (VCC), IC3.6 (VCC), IC3.18 (AVCC), IC3.20 (AREF)
V_PROG: D2.A, SL6.2

Notes on the sheet:
T_SOL_2
T_SOL_1
T_FEN
T_PRH
MOTOR
SOLDER
POWER
SUPLY
RELAY
PWM

Parts:
D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14: 1N4148DO35-7; DO35-7
HG1, HG2, HG3: BA56-12EWA; BX56-12
IC5, IC7, IC9: 74LS595D; SO16
IC6, IC8: ULN2003AD; SO16
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14: LEDSQR2X5; LED2X5
LED15, LED16, LED17: DUOLED2X5
R33, R34, R35, R36, R37, R38, R39, R40: R-EU_0204/5; 0204/5
S1, S2, S3, S4, S5, S6, S7, S8, S9, S10, S11, S12: 10-XX; B3F-10XX
SL13: DISPLAY; 06P

Connections:
+5V_D: IC5.10 (SCL), IC5.16 (VCC), IC7.10 (SCL), IC7.16 (VCC), IC9.10 (SCL), IC9.16 (VCC), SL13.5
CLK_D: IC5.11 (SCK), IC7.11 (SCK), IC9.11 (SCK), SL13.1
DATA_D: IC5.14 (SER), SL13.3
DP: HG1.3 (DP), HG2.3 (DP), HG3.3 (DP), LED5.A, LED12.A, LED17.AG, R35.2
GND_D: IC5.8 (GND), IC5.13 (G), IC6.8 (GND), IC7.8 (GND), IC7.13 (G), IC8.8 (GND), IC9.8 (GND), IC9.13 (G), SL13.6
KEY_D: S1.3, S1.4 (P1), S2.3, S2.4 (P1), S3.3, S3.4 (P1), S4.3, S4.4 (P1), S5.3, S5.4 (P1), S6.3, S6.4 (P1), S7.3, S7.4 (P1), S8.3, S8.4 (P1), S9.3, S9.4 (P1), S10.3, S10.4 (P1), S11.3, S11.4 (P1), S12.3, S12.4 (P1), SL13.4
L_01: D6.C, IC6.16 (O1), LED15.K (C), LED16.K (C), LED17.K (C)
L_02: D7.C, HG2.12 (CA), IC6.15 (O2)
L_03: D4.C, HG1.8 (CA), IC6.14 (O3)
L_04: D5.C, HG1.9 (CA), IC6.13 (O4)
L_05: D3.C, HG1.12 (CA), IC6.12 (O5)
L_06: D8.C, IC6.11 (O6), LED1.K (C), LED2.K (C), LED3.K (C), LED4.K (C), LED5.K (C), LED6.K (C), LED7.K (C)
L_07: D14.C, HG3.12 (CA), IC8.16 (O1)
L_08: D11.C, IC8.15 (O2), LED8.K (C), LED9.K (C), LED10.K (C), LED11.K (C), LED12.K (C), LED13.K (C), LED14.K (C)
L_09: D12.C, HG3.8 (CA), IC8.14 (O3)
L_10: D13.C, HG3.9 (CA), IC8.13 (O4)
L_11: D10.C, HG2.8 (CA), IC8.12 (O5)
L_12: D9.C, HG2.9 (CA), IC8.11 (O6)
unnamed: IC9.7 (QH), R33.1
unnamed: IC9.6 (QG), R34.1
unnamed: IC9.5 (QF), R35.1
unnamed: IC9.4 (QE), R36.1
unnamed: IC9.3 (QD), R37.1
unnamed: IC9.2 (QC), R38.1
unnamed: IC9.1 (QB), R39.1
unnamed: IC9.15 (QA), R40.1
unnamed: D3.A, S1.1 (S), S1.2 (S1)
unnamed: D4.A, S2.1 (S), S2.2 (S1)
unnamed: D5.A, S3.1 (S), S3.2 (S1)
unnamed: D6.A, S4.1 (S), S4.2 (S1)
unnamed: D7.A, S5.1 (S), S5.2 (S1)
unnamed: D8.A, S6.1 (S), S6.2 (S1)
unnamed: D9.A, S7.1 (S), S7.2 (S1)
unnamed: D10.A, S8.1 (S), S8.2 (S1)
unnamed: D11.A, S9.1 (S), S9.2 (S1)
unnamed: D12.A, S10.1 (S), S10.2 (S1)
unnamed: D13.A, S11.1 (S), S11.2 (S1)
unnamed: D14.A, S12.1 (S), S12.2 (S1)
unnamed: IC5.7 (QH), IC6.1 (I1)
unnamed: IC5.6 (QG), IC6.2 (I2)
unnamed: IC5.5 (QF), IC6.3 (I3)
unnamed: IC5.4 (QE), IC6.4 (I4)
unnamed: IC5.3 (QD), IC6.5 (I5)
unnamed: IC5.2 (QC), IC6.6 (I6)
unnamed: IC5.1 (QB), IC6.7 (I7)
unnamed: IC7.7 (QH), IC8.1 (I1)
unnamed: IC7.6 (QG), IC8.2 (I2)
unnamed: IC7.5 (QF), IC8.3 (I3)
unnamed: IC7.4 (QE), IC8.4 (I4)
unnamed: IC7.3 (QD), IC8.5 (I5)
unnamed: IC7.2 (QC), IC8.6 (I6)
unnamed: IC7.1 (QB), IC8.7 (I7)
unnamed: IC7.9 (QH*), IC9.14 (SER)
unnamed: IC5.9 (QH*), IC7.14 (SER)
SEG_A: HG1.11 (A), HG2.11 (A), HG3.11 (A), LED1.A, LED8.A, LED16.AG, R38.2
SEG_B: HG1.7 (B), HG2.7 (B), HG3.7 (B), LED15.AG, R40.2
SEG_C: HG1.4 (C), HG2.4 (C), HG3.4 (C), LED6.A, LED13.A, R33.2
SEG_D: HG1.2 (D), HG2.2 (D), HG3.2 (D), LED4.A, LED11.A, R36.2
SEG_E: HG1.1 (E), HG2.1 (E), HG3.1 (E), LED3.A, LED10.A, LED15.AR, R37.2
SEG_F: HG1.10 (F), HG2.10 (F), HG3.10 (F), LED2.A, LED9.A, LED16.AR, R39.2
SEG_G: HG1.5 (G), HG2.5 (G), HG3.5 (G), LED7.A, LED14.A, LED17.AR, R34.2
STROB_D: IC5.12 (RCK), IC7.12 (RCK), IC9.12 (RCK), SL13.2

Parts:
BR1: RECTIFIER-2KBP; 2KBP
C13: CPOL-EUE7.5-18; E7,5-18
C14, C15, C26, C27, C28, C35: C-EU050-025X075; C050-025X075
C16, C21: CPOL-EUE2.5-5; E2,5-5
C17, C18, C19: C-EU102-043X133; C102-043X133
C20: C-EU050-035X075; C050-035X075
C22, C23, C24: C-EU050-030X075; C050-030X075
C25, C29: CPOL-EUE5-13; E5-13
C30, C31, C32, C33, C34, C36, C37: CPOL-EUE5-10.5; E5-10,5
CX1: CXXC15B6; XC15B6
D18, D21: 1N4148DO35-10; DO35-10
D19: P6KEXXAV; RAD5G
D20: UF4003; DO41-10
D22, D24, D25: 1N5400V; RAD5G
D23: DIODE-2AC|CATO220V; TO220ABS
F1, F2: FUSESHK20L; SHK20L
HS1: HS-135; SK104-PAD
HS2: HS-123
IC10, IC11: 78XXS
K1, K2: 4052; F4052
L1, L2, L3: BS11
LF1: LF; LF-10X13
OK1, OK2, OK3: MOC3063-SC; DIL06
OK4: PC817; DIL04
Q1, Q2: IRFIZ24N; TO220BV
R41, R43, R57: R-EU_0207/10; 0207/10
R42, R44, R58, R59, R60: R-EU_0414/5V; 0414V
R45, R46, R47, R61, R62: R-EU_0204/7; 0204/7
R48, R49, R51, R52, R53, R54, R55, R56: R-EU_0613/5V; P0613V
R50: NTC642-6; P642
R63, R64, R65: R-EU_0411/3V; 0411V
R66, R68, R69: R-TRIMM3296W; RTRIM3296W
R67: R-EU_0207/2V; 0207/2V
SL14: POWER; 02P
SL15, SL16: M05; 05P
SL17: SOLDER; 03P
SL18: ON_OFF; 02P
SL19, SL20, SL21: M04; 04P
SL22, SL23, SL24, SL25: M02; 02P
SL26: FAN; 02P
SL27: R_EXT; 02PA
SL28: R_PRH; 02PA
T2, T3, T4: BTA12-600CWRG; TO220DS
U1: TOP-256YN; TO-220-7C
U$1: ETD-34V; 14PIN_VERTIKAL
VR1: TL431CLP; TO92-CLP
X1, X2, X3, X4, X5: W237-02P; W237-132

Connections:
+5V_P: C37.+, IC11.OUT, SL22.1
+12V_P: C36.+, D18.C, D21.C, IC10.OUT, K1.1, K2.1, SL23.2, SL24.2, SL26.1, SL27.2, SL28.2
+24V_P: C34.+, L3.2, R68.3 (A), SL19.3, SL19.4, SL20.3, SL20.4, SL25.2
AC1: F2.1A (1), R54.2, R55.2, R56.2, R58.2, R59.2, R60.2, T2.A2, T3.A2, T4.A2
AC2: K1.O1 (O), K1.P1, X1.2, X4.2, X5.2
GND_P: C20.2, C25.-, C26.2, C27.2, C28.2, C29.-, C30.-, C31.-, C32.-, C33.-, C34.-, C36.-, C37.-, IC10.GND, IC11.GND, OK1.2 (C), OK2.2 (C), OK3.2 (C), Q1.S, Q2.S, R69.3 (A), SL14.1, SL15.4, SL15.5, SL16.4, SL16.5, SL17.2, SL21.4, SL22.2, SL26.2, U$1.9, U$1.11, VR1.A
unnamed: CX1.1, F1.1A (1), LF1.2, R48.1
unnamed: F1.2A (2), X2.1
unnamed: CX1.2, LF1.1, R49.2, R50.1
unnamed: D22.A, U$1.7 (1)
unnamed: BR1.AC1, LF1.4
unnamed: C35.2, R68.1 (E), R68.2 (S), R69.1 (E), R69.2 (S), VR1.R
unnamed: BR1.AC2, LF1.3
unnamed: K2.P1, K2.P2, R50.2, SL18.1
unnamed: SL21.3, SL23.1
unnamed: SL21.2, SL24.1
unnamed: SL21.1, SL25.1
unnamed: F2.2A (2), X1.1
unnamed: K2.S1 (S), K2.S2 (S), SL18.2, X2.2
unnamed: Q1.G, R61.2
unnamed: Q1.D, SL19.1, SL19.2
unnamed: Q2.G, R62.2
unnamed: Q2.D, SL20.1, SL20.2
unnamed: C16.+, R57.1
unnamed: R41.1, R43.1
unnamed: R43.2, U1.V
unnamed: D20.A, U1.D, U$1.3 (1)
unnamed: BR1.+, C13.+, C14.1, C20.1, D19.A, R41.2, R42.2, R44.2, U$1.1
unnamed: C14.2, D19.C, D20.C, R42.1, R44.1
unnamed: C15.1, OK4.3 (EMIT), R57.2, U1.C
unnamed: R48.2, R49.1
unnamed: D23.A1, D23.A2, R63.1, U$1.14
unnamed: C22.2, C25.+, C28.1, C29.+, D23.C, L3.1, R66.3 (A)
unnamed: D24.A, R64.1, U$1.10
unnamed: OK1.6 (A2), R54.1
unnamed: C22.1, R63.2
unnamed: C23.1, R64.2
unnamed: C24.1, R65.2
unnamed: D25.A, R65.1, U$1.8
unnamed: C23.2, C26.1, C30.+, D24.C, L1.1
unnamed: C32.+, IC10.IN, L1.2
unnamed: C24.2, C27.1, C31.+, D25.C, L2.1
unnamed: OK1.4 (A1), R51.2, T2.G (G1)
unnamed: C33.+, IC11.IN, L2.2
unnamed: C17.1, R58.1
unnamed: C35.1, OK4.2 (C), R67.1, VR1.C
unnamed: C21.+, D22.C, OK4.4 (COL)
unnamed: OK4.1 (A), R66.1 (E), R66.2 (S), R67.2
unnamed: BR1.-, C13.-, C15.2, C16.-, C21.-, U1.G, U1.S, U1.X, U$1.6 (1)
unnamed: C17.2, K1.O2 (O), K1.P2, R51.1, T2.A1
unnamed: OK1.1 (A), R45.2
unnamed: K1.S2 (S), X3.2
unnamed: K1.S1 (S), X3.1
unnamed: OK2.6 (A2), R55.1
unnamed: OK2.4 (A1), R52.2, T3.G (G1)
unnamed: C18.1, R59.1
unnamed: OK2.1 (A), R46.2
unnamed: C18.2, R52.1, T3.A1, X4.1
unnamed: OK3.6 (A2), R56.1
unnamed: OK3.4 (A1), R53.2, T4.G (G1)
unnamed: C19.1, R60.1
unnamed: OK3.1 (A), R47.2
unnamed: C19.2, R53.1, T4.A1, X5.1
POWER_P: D21.A, K2.2, SL14.2
PWM_EXT_P: R46.1, SL15.2
PWM_FEN_P: R45.1, SL15.3
PWM_PRH_P: R47.1, SL15.1
R_EXT_P: SL16.2, SL27.1
R_FEN_P: D18.A, K1.2, SL16.3
R_PRH_P: SL16.1, SL28.1
SOL_1: R61.1, SL17.3
SOL_2: R62.1, SL17.1

Notes on the sheet:
FEN_HEAT
EXTERNAL
PREHEAT
SOLDER_1
SOLDER_2
M_AIR
M_PREHEAT
M_FEN
MOTOR
SUPLY
PWM
RELAY
~220V
TR1

Notes on the sheet:
144mm
130mm

Board: 2 copper layers, 144.0 x 230.0 mm, 230 parts (67 on the bottom side), 192 nets.

## Commit log

2016-04-22 a001
2016-04-22 a002
2016-04-22 a003
2016-05-18 add DSS-3M1 DSS3_T12
2016-06-25 size plate
2016-07-11 add ds sw
2016-08-26 a004
2016-08-26 a005
2016-08-26 a006
2017-07-17 a008
2018-07-30 Backlink to CADLAB.io has been added.
2018-07-31 usb fix
2018-07-31 gnd+1
2018-07-31 +pow
2018-07-31 sw 5
2018-08-01 bak2
2018-08-01 bak con
2018-08-01 opt1
2018-08-01 end w
2018-08-01 lbak
2018-08-01 -epf
2018-08-01 +epf
2018-08-02 topsilk
2018-08-02 lab bot
2018-08-02 layfix
2018-08-06 bak bv
2018-08-06 fix bad
2018-10-29 add buzzer
2018-11-02 stop
2018-11-11 add con pwr
2019-04-14 pwtst1
2019-04-14 test2
2019-04-14 test3
2019-04-15 r cpu
2019-04-15 4page
2019-04-16 h 4-14
2019-04-18 r4 top fet
2019-04-18 r sch
2019-04-18 r4 3
2019-04-18 temp1
2019-05-03 sw con
2019-05-03 pow2
2019-05-04 stop12v
